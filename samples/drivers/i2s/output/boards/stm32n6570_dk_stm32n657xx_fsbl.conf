## samples/drivers/i2s/output/boards/stm32n6570_dk_stm32n657xx_fsbl.conf
```kconfig
CONFIG_LOG=y
CONFIG_AUDIO=y
CONFIG_AUDIO_CODEC=y
CONFIG_HEAP_MEM_POOL_SIZE=32768
```
